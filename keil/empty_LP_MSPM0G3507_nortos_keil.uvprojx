# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "E:\ti\mspm0_sdk_2_09_00_01\tools\keil\syscfg.bat '$P' empty.syscfg"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;../driver;../library;../logic;E:\ti\mspm0_sdk_2_09_00_01\source\third_party\CMSIS\Core\Include;E:\ti\mspm0_sdk_2_09_00_01\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: E:\ti\mspm0_sdk_2_09_00_01\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group system_config
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c
    ./: startup_mspm0g350x_uvision.s
  group driver
    ../driver/: bsp_system.h icm42688_driver.c red_gray_driver.c encoder_driver.c button_driver.c motor_driver.c uart_driver.c imu_driver.c lf_04.c pid.c Time.c
  group logic
    ../logic/: scheduler.c imu_imu_app.c user_motor.c uart_app.c gray_app.c oled_app.c imu_app.c user_pid.c
  group library
    ../library/: OLED.c OLED.h OLED_FONT.h ringbuffer.c ringbuffer.h
